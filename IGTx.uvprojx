# Keil uVision project IGTx.uvprojx, settings and files
target BareTemplate (6210000::V6.21::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IGTx
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -Wno-invalid-source-encoding -Wno-deprecated-non-prototype
  c include: D:\Libraries\STM32\HAL\STM32Cube_FW_F4_V1.27.1\Drivers\CMSIS\Include;D:\Libraries\STM32\HAL\STM32Cube_FW_F4_V1.27.1\Drivers\STM32F4xx_HAL_Driver\Inc;D:\Libraries\STM32\HAL\STM32Cube_FW_F4_V1.27.1\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Core\System\Common\Inc;.\Core\System\Configs\Inc;.\Core\System\Helpers\Inc;.\Core\System;.\Core\DAO\Inc;.\Core\Helpers\Inc;.\Core\Libraries\Inc;.\Core\Services\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System/Startup
    ./Core/System/Startup/: main.c
    ./Core/System/Startup/arm/: startup_stm32f407xx.s
  group System/Configs
    ./Core/System/Configs/Src/: system_conf.c
  group System/Common
    ./Core/System/Common/Src/: gpio_it.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group System/Helpers
    ./Core/System/Helpers/Src/: delay_helper.c serial_helper.c sram_helper.c
  group System/Peripherals
    ./Core/System/Peripherals/: peripheral_index.c
    ./Core/System/Peripherals/can/: can.c can_it.c
    ./Core/System/Peripherals/dma/: dma.c dma_it.c
    ./Core/System/Peripherals/iwdg/: iwdg.c iwdg_it.c
    ./Core/System/Peripherals/spi/: spi.c spi_it.c
    ./Core/System/Peripherals/tim/: tim.c tim_it.c
    ./Core/System/Peripherals/uart/: uart.c uart_it.c
  group System/Drivers
    ./Core/System/Drivers/: stm32f4xx_hal.c
    D:/Libraries/STM32/HAL/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_sdmmc.c
  group System/BSP
    ./Core/System/BSP/: bsp_index.c
    ./Core/System/BSP/key/: key.c
    ./Core/System/BSP/led/: led.c
  group DAO
    ./Core/DAO/Src/: can_dao.c
  group Services
    ./Core/Services/Src/: system_service.c
